# Keil uVision project key_7segment.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: key_7segment
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\inc;..\..\..\lpc175x_6x_cmsis_driver_library\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../../src/: main.c
  group Periph_Drivers
    ../../../lpc175x_6x_cmsis_driver_library/Drivers/source/: lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_clkpwr.c lpc17xx_gpio.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
